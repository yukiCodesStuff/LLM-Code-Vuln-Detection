			pmx_led_wifi_yellow: pmx-led-wifi-yellow {
				marvell,pins = "mpp48";
				marvell,function = "gpio";
			};
		};

		serial@12000 {
			status = "ok";
		};

		nand@3000000 {
			status = "okay";

			partition@0 {
				label = "u-boot";
				reg = <0x0000000 0x180000>;
			};

			partition@180000 {
				label = "u-boot env";
				reg = <0x0180000 0x20000>;
			};

			partition@200000 {
				label = "uImage";
				reg = <0x0200000 0x600000>;
			};

			partition@800000 {
				label = "uInitrd";
				reg = <0x0800000 0x1000000>;
			};

			partition@1800000 {
				label = "rootfs";
				reg = <0x1800000 0xe800000>;
			};
		};

		sata@80000 {
			status = "okay";
			nr-ports = <1>;
		};

		i2c@11000 {
			status = "ok";
		};

		mvsdio@90000 {
			pinctrl-0 = <&pmx_sdio>;
			pinctrl-names = "default";
			status = "okay";
			/* No CD or WP GPIOs */
		};
	};

	gpio-leds {
		compatible = "gpio-leds";

		disk {
			label = "topkick:yellow:disk";
			gpios = <&gpio0 21 1>;
			linux,default-trigger = "ide-disk";
		};
		system2 {
			label = "topkick:red:system";
			gpios = <&gpio1 5 1>;
		};
		system {
			label = "topkick:blue:system";
			gpios = <&gpio1 6 1>;
			default-state = "on";
		};
		wifi {
			label = "topkick:green:wifi";
			gpios = <&gpio1 7 1>;
		};
		wifi2 {
			label = "topkick:yellow:wifi";
			gpios = <&gpio1 16 1>;
		};
	};
	regulators {
		compatible = "simple-bus";
		#address-cells = <1>;
		#size-cells = <0>;

		sata0_power: regulator@1 {
			compatible = "regulator-fixed";
			reg = <1>;
			regulator-name = "SATA0 Power";
			regulator-min-microvolt = <5000000>;
			regulator-max-microvolt = <5000000>;
			enable-active-high;
			regulator-always-on;
			regulator-boot-on;
			gpio = <&gpio1 4 0>;
		};
	};
};