		};
	};

	cci: cci@10d20000 {
		compatible = "arm,cci-400";
		#address-cells = <1>;
		#size-cells = <1>;
		reg = <0x10d20000 0x1000>;
	};

	dp_phy: video-phy@10040728 {
		compatible = "samsung,exynos5420-dp-video-phy";
		samsung,pmu-syscon = <&pmu_system_controller>;
		#phy-cells = <0>;
	};

	dp: dp-controller@145B0000 {